Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-06-28T17:47:47
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Kastello Concealed Shower Mixer W/o U-Box, FFAS1622-708500ZC0:Kastello Concealed Shower Mixer W/o U-Box:3866
In: Level 1
Classification: D2010700 (Uniformat); Material: Chrome
Pset_ManufacturerTypeInformation - ModelReference: Kastello Concealed Shower Mixer W/o U-Box; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Kastello Concealed Shower Mixer W/o U-Box
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0565769 m2; Volume: 0.000901374 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: FFAS1622-708500ZC0: Kastello Concealed Shower Mixer W/o U-Box; Family and Type: FFAS1622-708500ZC0: Kastello Concealed Shower Mixer W/o U-Box; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: FFAS1622-708500ZC0: Kastello Concealed Shower Mixer W/o U-Box; Type Id: FFAS1622-708500ZC0: Kastello Concealed Shower Mixer W/o U-Box; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: G1/2 in; FlowRate: For shower outlet: 13.9 litre per minute; InstallationType: Wall Mount; ProductCategory: Bathroom Fittings (40); ProductGroup: Shower Mixer (03); ProductWeight: 1.9 kg; StyleSegment: Classic; SubCategory: Bathroom Faucets (Mixer) (41)
Identity Data(Type) - Assembly Code: D2010700; Description: Kastello Concealed Shower Mixer W/o U-Box; Keynote: N13; Manufacturer: American Standard; Model: Kastello Concealed Shower Mixer W/o U-Box; OmniClass Number: 23.45.05.14.17; OmniClass Title: Showers; Type Comments: FFAS1622-708500ZC0; Type Name: Kastello Concealed Shower Mixer W/o U-Box; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffas1622-708500zc0/document/object-user-guide; BIMObjectName: AmericanStandard_ShowerMixer_Kastello_(FFAS1622-708500ZC0); NBSDescription: Shower mixers; NBSNote: n/a; NBSObjectName: American Standard - Shower mixers; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/335
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_81; CodePerformance: n/a; Color: Chrome; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffas1622-708500zc0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffas1622-708500zc0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffas1622-708500zc0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffas1622-708500zc0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffas1622-708500zc0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: FFAS1622-708500ZC0; Features: n/a; Finish: Chrome; Grade: n/a; ManufacturerName: American Standard; Material: Brass; ModelNumber: FFAS1622-708500ZC0; ModelReference: Kastello Concealed Shower Mixer W/o U-Box; ProductionYear: 2021; ReferencedStandard: GB 18145-2014; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Kastello Concealed Shower Mixer W/o U-Box; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
